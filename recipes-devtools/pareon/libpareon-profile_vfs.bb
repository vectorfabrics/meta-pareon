PAREON_PRODUCT = "profile"

require libpareon.inc
