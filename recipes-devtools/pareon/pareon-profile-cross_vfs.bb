PAREON_PRODUCT = "profile"

require pareon-cross.inc

DESCRIPTION = "Wrapper script for the Pareon Profile compiler"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://${PAREON_DIR}/EULA.exec;md5=1c43b59db6eab4e68de95551563c708b"
